# Keil uVision project UCOSII-1.uvprojx, settings and files
target UCOSII-1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: UCOSII-1 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c misc: --c99
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\UCOSII\CONFIG;..\UCOSII\CORE;..\UCOSII\PORT;..\CANOPEN;..\CANOPEN\Include;..\HARDWARE\CAN;..\HARDWARE\TIMER
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/CAN/: mycan.c
    ../HARDWARE/TIMER/: mytimer.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_dbgmcu.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_can.c
  group UCOSII-CORE
    ../UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII-PORT
    ../UCOSII/PORT/: os_cpu_a.asm os_cpu_c.c os_cpu.h
  group UCOSII-CONFIG
    ../UCOSII/CONFIG/: includes.h os_cfg.h
  group README
    ../: README.TXT
  group CANOPEN
    ../CANOPEN/: stm32f1_canfestival.c EwtCanAnalysis_objdict.c
    ../CANOPEN/Src/: dcf.c emcy.c lifegrd.c lss.c nmtMaster.c nmtSlave.c objacces.c pdo.c sdo.c states.c sync.c timer.c
